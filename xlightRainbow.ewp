# IAR project xlightRainbow.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; XRAINBOW
  ICCSTM8.CCIncludePath2: ..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\inc; $PROJ_DIR$; Project\inc; ..\xlightCommon-stm8s\Xlight_lib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: sunnyv1.0.1.0_SDTM.hex
  ILINK.IlinkOutputFile: xlightRainbow.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: STM8S105; NDEBUG
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; $PROJ_DIR$
  group STM8S Library/inc
    ../xlightCommon-stm8s/STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_uart2.h stm8s_wwdg.h
  group STM8S Library/src
    ../xlightCommon-stm8s/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
  group User/common
    ../xlightCommon-stm8s/Xlight_lib/: debugDefine.h delay.c delay.h FlashDataStorage.c FlashDataStorage.h MyMessage.h publicDefine.h rf24l01.c rf24l01.h stm8s_conf.h timer_4.c timer_4.h Uart2Dev.c Uart2Dev.h wwdg.c wwdg.h
  group User/inc
    Project/inc/: _global.h ADC1Dev.h color_factory.h LightPwmDrv.h ProtocolParser.h stm8s_conf.h stm8s_it.h xliNodeConfig.h
  group User/src
    Project/src/: ADC1Dev.c color_factory.c LightPwmDrv.c main.c ProtocolParser.c
